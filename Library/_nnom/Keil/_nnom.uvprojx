# Keil uVision project _nnom.uvprojx, settings and files
target nnomLib (6190000::V6.19::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: nnomLib (library)
  AfterMake: cmd.exe /C copy /Y Objects\nnomLib.lib ..\nnomLib_Keil.lib
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\CMSIS\Include;..\..\Device\Nuvoton\m460\Include;..\..\StdDriver\inc;..\Include;..\Include\layers;..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group core
    ../Source/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
  group backends
    ../Source/backends/: nnom_local.c nnom_local_q15.c
  group layers
    ../Source/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_reshape.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
